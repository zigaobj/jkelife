# Keil uVision project Si4431Mst.uvproj, settings and files
target 24L01TxMst (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: M24L01_101013 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_HD
  c include: .\Libraries_V3.3.0\CMSIS\CM3\CoreSupport;.\Libraries_V3.3.0\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries_V3.3.0\STM32F10x_StdPeriph_Driver\inc;.\Source\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./Source/src/: main.c stm32f10x_it.c 24L01API.c UsartCom.c Init.c SPICom.c 24L01App.c Global.c
  group Startup
    ./Libraries_V3.3.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Library
    ./Libraries_V3.3.0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c
    ./Libraries_V3.3.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Document
    ./Document/: 调试情况.txt 协议.txt
